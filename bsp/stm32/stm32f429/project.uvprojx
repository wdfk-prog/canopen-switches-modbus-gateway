# Keil uVision project project.uvprojx, settings and files
target rt-thread (6190000::V6.19::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c define: LFS_CONFIG=lfs_config.h, USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC, STM32F429xx
  c misc: -Wno-invalid-source-encoding -Wno-logical-not-parentheses
  c include: board;board\CubeMX_Config\Inc;board\ports;applications;.;BoardDriver;.;packages\CanFestival-latest\inc;packages\CmBacktrace-latest;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\drv_flash;..\..\..\components\fal\inc;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\romfs;..\..\..\components\finsh;packages\FlashDB-latest\inc;packages\freemodbus-v1.5.0\modbus;.;packages\freemodbus-v1.5.0\modbus;packages\freemodbus-v1.5.0\modbus\include;packages\freemodbus-v1.5.0\modbus\rtu;.;..\..\..\include;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include;packages\littlefs-latest;packages\CanFestival-latest\master402;.;packages\CanFestival-latest\master402;packages\MFBD-latest;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;packages\SignalLed-latest\inc;packages\SignalLed-latest;packages\syswatch-latest\inc;..\..\..\components\utilities\ulog;..\..\..\components\utilities\ymodem
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group APP/Drivers
    board/CubeMX_Config/Src/: gpio.c dma.c spi.c tim.c iwdg.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c can.c fmc.c rtc.c system_stm32f4xx.c adc.c usart.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    board/ports/: spi_flash_init.c
  group Applications
    applications/: user_math.c mb_key.c mb_handler.c monitor.c bsp_key.c README.md
  group BoardDriver
    BoardDriver/: motor.c turn_motor.c motor_cycle.c user_can.c Smove.c modbus_slave2.c ulog_file_be.c led.c adc_dma.c Trapezoidal.c filesystem.c walk_motor.c modbus_slave1.c lifter_motor.c
  group CanFestival
    packages/CanFestival-latest/src/: emcy.c pdo.c objacces.c timer_rtthread.c timer.c can_rtthread.c states.c sdo.c nmtSlave.c sync.c lifegrd.c nmtMaster.c
  group cm_backtrace
    packages/CmBacktrace-latest/: cmb_port.c cm_backtrace.c cmb_flash_log.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/ipc/: ringblk_buf.c dataqueue.c waitqueue.c ringbuffer.c completion.c workqueue.c pipe.c
    ../../../components/drivers/misc/: rt_drv_pwm.c pulse_encoder.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial_v2.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_pulse_encoder.c drv_can.c drv_sdram.c drv_usart_v2.c drv_spi.c drv_wdt.c drv_common.c drv_rtc.c drv_pwm.c drv_hwtimer.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group Fal
    ../../../components/fal/src/: fal_partition.c fal.c fal_flash.c fal_rtt.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/romfs/: romfs.c dfs_romfs.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group FlashDB
    packages/FlashDB-latest/src/: fdb_kvdb.c fdb_file.c fdb_utils.c fdb_tsdb.c fdb_cmd.c fdb.c
  group FREEMODBUS/V1.5
    packages/freemodbus-v1.5.0/modbus/rtu/: mbcrc.c mbrtu.c
    packages/freemodbus-v1.5.0/modbus/functions/: mbutils.c mbfuncdiag.c mbfuncinput.c mbfuncholding.c mbfunccoils.c mbfuncdisc.c mbfuncother.c
    packages/freemodbus-v1.5.0/modbus/: mb.c mbevent.c
  group Kernel
    packages/rt_memcpy_cm-latest/: rt_memcpy_rvds.S
    ../../../src/: components.c scheduler.c clock.c object.c kservice.c memheap.c timer.c device.c idle.c mempool.c mem.c thread.c irq.c ipc.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_cec.c stm32f4xx_hal_flash.c stm32f4xx_ll_fmc.c
  group littlefs
    packages/littlefs-latest/: lfs_util.c lfs.c lfs_crc.c dfs_lfs.c
  group Master402
    packages/CanFestival-latest/master402/: master402_od.c canopen_callback.c master402_canopen.c motor_control.c
  group mfbd
    packages/MFBD-latest/: mfbd.c
  group rt_kprintf
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group SignalLed
    packages/SignalLed-latest/src/: signal_led.c
  group syswatch
    packages/syswatch-latest/src/: syswatch_test.c syswatch.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
    ../../../components/utilities/ymodem/: ry_sy.c ymodem.c
